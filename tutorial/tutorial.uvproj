# Keil uVision project tutorial.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2468 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x4000FFFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: tutorial
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0xa0000000 size 0x20000000
  memory RVCT9: RAM 0x40000000 size 0x10000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group Startup Codes
    ./: LPC2400.s
  group Application Code
    ./: main.c
